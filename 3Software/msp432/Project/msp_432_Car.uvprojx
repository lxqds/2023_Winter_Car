# Keil uVision project msp_432_Car.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msp_432_Car
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\Libraries\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\Users;..\Hardware\encoder;..\Hardware\key;..\Hardware\led;..\Hardware\motor;..\Hardware\oled;..\Hardware\reflectance;..\Hardware\servo;..\Hardware\sys;..\Hardware\tim32;..\Hardware\timA;..\Hardware\uart1;..\Hardware\IIC;..\Hardware\IIC\eMPL;..\Hardware\protocol;..\Hardware\pid;..\Users\Control;..\Users\app;..\Hardware\k210;..\Hardware\communicate
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Users
    ../Users/: main.c myconfig.c myconfig.h
  group Lib
    ../Libraries/ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../Hardware/encoder/: bsp_encoder.c
    ../Hardware/key/: key.c
    ../Hardware/led/: led.c
    ../Hardware/motor/: bsp_motor.c
    ../Hardware/oled/: oled.c
    ../Hardware/reflectance/: Reflectance.c
    ../Hardware/servo/: bsp_Servo.c
    ../Hardware/tim32/: tim32.c
    ../Hardware/timA/: timA.c
    ../Hardware/uart1/: usart.c
  group Sys
    ../Hardware/sys/: baudarte.c sysinit.c delay.c
  group Doc
    ../Doc/: bsp_xx.c bsp_xx.h Read me.txt
  group IIC
    ../Hardware/IIC/: IIC.c IIC.h bsp_MPU6050.c bsp_MPU6050.h
    ../Hardware/IIC/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group pid
    ../Hardware/pid/: bsp_pid.c bsp_pid.h
  group protocal
    ../Hardware/protocol/: protocol.c protocol.h
  group Control
    ../Users/Control/: Control.c Control.h
  group k210
    ../Hardware/k210/: k210.c k210.h
  group communicate
    ../Hardware/communicate/: communicate.c communicate.h
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.2

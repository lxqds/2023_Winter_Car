# Keil uVision project msp432_Newproject.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: msp432_Newproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: .\inc
  asm include: .\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c system_msp432p401r.c startup_msp432p401r_uvision.s
  group lib
    ./src/: adc14.c aes256.c comp_e.c crc32.c cs.c dma.c flash.c flash_a.c fpu.c gpio.c i2c.c interrupt.c lcd_f.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c sysctl_a.c systick.c timer_a.c timer32.c uart.c wdt_a.c
    ./: msp432p4xx_driverlib.lib

# Keil uVision project msp432_Car.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: msp432_Car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c include: .\sys\inc;.\hardware\inc;.\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;.\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include;.\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\ti\devices\msp432p4xx\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./: main.c
  group Hardware
    ./hardware/: bsp_exti.c bsp_motor.c Control.c key.c led.c oled.c Reflectance.c tim32.c timA.c
  group SYS
    ./sys/: baudarte.c delay.c sysinit.c usart.c
  group LIB
    ./ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 3.2.2
